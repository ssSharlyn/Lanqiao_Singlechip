# Keil uVision project 第14届省赛.uvproj, settings and files
target 第14届省赛 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 第14届省赛 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src\driver
  group user
    ../src/user/: main.c
  group driver
    ../src/driver/: sys.c sys.h key.c key.h seg.c seg.h led.c led.h ds1302.c ds1302.h iic.c iic.h onewire.c onewire.h
