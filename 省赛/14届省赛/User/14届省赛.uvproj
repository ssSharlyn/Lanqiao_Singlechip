# Keil uVision project 14届省赛.uvproj, settings and files
target 14届省赛 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 14届省赛 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: main.c
  group Driver
    ../Driver/: DS1302.c I2C.c Init.c Key.c LED.c OneWire.c Seg.c Uart.c
