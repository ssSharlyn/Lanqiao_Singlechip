# Keil uVision project 调度器.uvproj, settings and files
target 调度器 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 调度器 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src\driver
  group user
    ./: STARTUP.A51
    ../src/user/: main.c
  group driver
    ../src/driver/: system.c system.h key.c key.h seg.c seg.h led.c led.h uart.c uart.h ultrasonic.c ultrasonic.h iic.c iic.h onewire.c onewire.h ds1302.c ds1302.h
